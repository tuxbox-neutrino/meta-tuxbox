inherit features_check

REQUIRED_DISTRO_FEATURES:append = " qt5"
PR:append = ".1"
