PR:append = ".1"

DEPENDS:append = " nasm-native"
