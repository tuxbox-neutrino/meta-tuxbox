PR:append = ".2"

# Pin to the same commit used by meta-openembedded.
SRCREV = "bc6c0b164a87ce05e9925785cc6fb3f54c02b026"

# COPYING is GPL-2.0 (not LGPL).
LICENSE = "GPL-2.0-or-later"
