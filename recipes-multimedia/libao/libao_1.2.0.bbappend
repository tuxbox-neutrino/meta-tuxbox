# Pin SRCREV for the oe-alliance git recipe to avoid AUTOREV lookups.
SRCREV = "cafce902a73c1050474a62feff83e428bbbee5f4"
