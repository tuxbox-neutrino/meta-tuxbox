PR:append = ".1"

# Pin to the 1.4.3 tag to avoid AUTOREV network lookups during parsing.
SRCREV = "969cd043a6c8560a5dbdabe8c625e7f9b9a0a942"
