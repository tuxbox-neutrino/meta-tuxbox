PR:append = ".1"

FILES:${PN}-dev += "${libdir}/kodiplatform ${libdir}/kodiplatform/*"
