SRC_URI:append = " \
	file://0001-software-ipkg-lib-detect-opkg-correctly.patch \
"
