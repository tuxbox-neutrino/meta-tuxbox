PR:append = ".1"

# Upstream configure no longer supports this flag; keep build QA clean.
EXTRA_OECONF:remove = "--enable-enigma"
