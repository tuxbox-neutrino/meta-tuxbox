PE = "2"
PR:append = ".10"

inherit gitpkgv
PKGV = "${GITPKGV}"

# Track tested upstream hardening for startup/config IO paths.
SRCREV = "085c4197b667d12e05c72d48cd86545f2146efd0"
