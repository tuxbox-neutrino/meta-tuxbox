# Compatibility wrapper for recipes that still inherit "gittag".
# meta-tuxbox/gitpkgv.bbclass provides GITPKGV/GITPKGVTAG with
# Python-3 compatible implementation.
inherit gitpkgv
