PR:append = ".1"

# Pin SRCREV and use the GitHub mirror to avoid TLS fetch failures.
SRCREV = "41240764d2ce9fdd228c17401f10a30e2105bdbb"
SRC_URI = "git://github.com/videolan/bitstream.git;protocol=https;branch=master"
