# Avoid pkgfeed downgrades after switching from the previous git recipe.
PE = "1"
PR:append = ".1"
